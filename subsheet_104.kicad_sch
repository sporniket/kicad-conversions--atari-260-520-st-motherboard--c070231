File: subsheet_104.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: almost done dma controller and acsi port
Parts:
- added C7: 0.1uF, commons-passives_THT:Passive_THT_capacitor_mlcc_W2.54mm_L12.70mm, symbol Device:C_Small
- added J2: DB19S ACSI, symbol Connector_Generic_Shielded:Conn_01x19_Shielded
- added L24: Ferrite bead, commons-passives_THT:Passive_THT_ferrite_bead_W3.81mm_L15.24mm, symbol Device:Ferrite_Bead_Small
- added R103: 1K, symbol Device:R_Small_US
- added U1: ST_DMA_DIP40_PHY, Package_DIP:DIP-40_W15.24mm_LongPads, symbol st_dma_dip40:ST_DMA_DIP40_PHY
Connections:
- new net +5V: L24.2, R103.2
- new net +5VP: C7.1, L24.1, U1.40 (VCC)
- new net 8MHZ: U1.39 (CLK)
- new net A1: U1.2 (A1)
- new net ACK: J2.14 (Pin_14), U1.37 (~{ACK})
- new net ACSI_PORT_DRQ: J2.19 (Pin_19), R103.1
- new net ACSI_PORT_INT: J2.10 (Pin_10)
- new net CA1: J2.16 (Pin_16), U1.26 (CA1)
- new net CA2: U1.27 (CA2)
- new net CD0: J2.1 (Pin_1), U1.36 (CD0)
- new net CD1: J2.2 (Pin_2), U1.35 (CD1)
- new net CD2: J2.3 (Pin_3), U1.34 (CD2)
- new net CD3: J2.4 (Pin_4), U1.33 (CD3)
- new net CD4: J2.5 (Pin_5), U1.32 (CD4)
- new net CD5: J2.6 (Pin_6), U1.31 (CD5)
- new net CD6: J2.7 (Pin_7), U1.30 (CD6)
- new net CD7: J2.8 (Pin_8), U1.29 (CD7)
- new net CS: J2.9 (Pin_9), U1.24 (~{HDCS})
- new net D0: U1.4 (D0)
- new net D1: U1.5 (D1)
- new net D10: U1.14 (D10)
- new net D11: U1.15 (D11)
- new net D12: U1.16 (D12)
- new net D13: U1.17 (D13)
- new net D14: U1.18 (D14)
- new net D15: U1.19 (D15)
- new net D2: U1.6 (D2)
- new net D3: U1.7 (D3)
- new net D4: U1.8 (D4)
- new net D5: U1.9 (D5)
- new net D6: U1.10 (D6)
- new net D7: U1.11 (D7)
- new net D8: U1.12 (D8)
- new net D9: U1.13 (D9)
- new net DMA_FDCS: U1.22 (~{FDCS})
- new net DMA_FDRQ: U1.21 (FDRQ)
- new net DMA_RW: J2.18 (Pin_18), U1.25 (CR/~{W})
- new net GND: C7.2, J2.11 (Pin_11), J2.13 (Pin_13), J2.15 (Pin_15), J2.17 (Pin_17), J2.SH (Shield), U1.20 (GND), U1.28 (GND)
- new net XFCS: U1.3 (~{FCS})
- new net XRDY: U1.38 (RDY)
- new net XRESET: J2.12 (Pin_12)
- new net XRXW: U1.1 (R/~{W})
Other:
- note added: "A1"
- note added: "D0"
- note added: "D1"
- note added: "D2"
- note added: "D3"
- note added: "D4"
- note added: "D5"
- note added: "D6"
- note added: "D7"
- note added: "DRQ"
- note added: "INT"
- note added: "R /W"
- note added: "RESET"

Commit message: add floppy disk controller, port and 7406
Parts:
- added J3: Floppy disk, symbol Connector_Generic_Shielded:Conn_01x14_Shielded
- added L? (x12): Filter LCL, symbol Device:Filter_EMI_LCL
- added U8: 7406 HEX INVERTER, Package_DIP:DIP-14_W7.62mm_LongPads, symbol 74x06:74X06_HEX_INVERTER_BUFFERS_AND_DRIVERS_WITH_OPEN-COLLECTOR_HIGH-VOLTAGE_O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
- added U9: WD1772_FLOPPY_DISK_CONTROLLER_AND_FORMATTER_PHY, Package_DIP:DIP-28_W15.24mm_LongPads, symbol wd1772:WD1772_FLOPPY_DISK_CONTROLLER_AND_FORMATTER_PHY
Connections:
- net GND: now also J3.3 (Pin_3), J3.7 (Pin_7), J3.SH (Shield), L?.2, L?.2, L?.2, L?.2, L?.2, L?.2, L?.2, L?.2, L?.2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
- net DMA_FDCS renamed FDCS
- net FDCS: now also U9.1 (~{CS})
- net DMA_FDRQ: no longer names the net of U1.21 (FDRQ)
- net DMA_FDRQ: now also U9.27 (DRQ)
- new net: J3.9 (Pin_9), L?.3
- new net: J3.8 (Pin_8), L?.3
- new net: J3.1 (Pin_1), L?.3
- new net: J3.10 (Pin_10), L?.3
- new net: J3.11 (Pin_11), L?.3
- new net: J3.12 (Pin_12), L?.3
- new net: J3.13 (Pin_13), L?.3
- new net: J3.14 (Pin_14), L?.3
- new net: J3.2 (Pin_2), L?.3
- new net: J3.4 (Pin_4), L?.3
- new net: J3.5 (Pin_5), L?.3
- new net: J3.6 (Pin_6), L?.3
- new net: L?.1, U9.19 (~{RD})
- new net DRV0_SEL: L?.1
- new net DRV1_SEL: L?.1
- new net SIDE0_SEL: L?.1
- new net index: L?.1, U9.24 (~{IP})
- new net track_00: L?.1, U9.23 (~{TR00})
- new net write_protect: L?.1, U9.25 (~{WPRT})
Other:
- note added: "DIRECTION IN"
- note added: "DRIVE 0 SELECT"
- note added: "DRIVE 1 SELECT"
- note added: "From U19"
- note added: "GND"
- note added: "INDEX"
- note added: "MOTOR ON"
- note added: "READ DATA"
- note added: "SIDE 0 SELECT"
- note added: "STEP"
- note added: "TRACK 00"
- note added: "WRITE DATA"
- note added: "WRITE GATE"
- note added: "WRITE PROTECT"

Commit message: completing floppy disk
Parts:
- added C14, C8: 0.1uF, commons-passives_THT:Passive_THT_capacitor_mlcc_W2.54mm_L12.70mm, symbol Device:C_Small
- added R100, R101: 47, symbol Device:R_Small_US
- added R102: 4K7, symbol Device:R_Small_US
- gave numbers to parts that had none: 1
Connections:
- net ACSI_PORT_DRQ is gone; now on net DRQ: J2.19 (Pin_19), R103.1
- net +5V: now also U8.14 (VCC), C14.1, R102.1
- net +5VP: now also U9.15 (VCC), C8.1
- net 8MHZ: now also U9.18 (CLK)
- net CA1: now also U9.3 (A0)
- net CA2: now also U9.4 (A1)
- net CD0: now also U9.5 (DAL0)
- net CD1: now also U9.6 (DAL1)
- net CD2: now also U9.7 (DAL2)
- net CD3: now also U9.8 (DAL3)
- net CD4: now also U9.9 (DAL4)
- net CD5: now also U9.10 (DAL5)
- net CD6: now also U9.11 (DAL6)
- net CD7: now also U9.12 (DAL7)
- net DMA_RW: no longer U1.25 (CR/~{W})
- net GND: now also U8.7 (GND), U9.14 (GND), U9.26 (~{DDEN}), C14.2, C8.2
- net XRESET: now also U9.13 (~{MR})
- net at L?.1: now also U8.6 (3Y)
- net motor_on: now reaches L?.1
- net motor_on: now also U8.12 (6Y)
- net HDRQ: now reaches U1.23 (HDRQ)
- net HDRQ: now also U8.2 (1Y), R102.2
- net wd_step: now reaches U9.16 (STEP)
- net wd_step: now also U8.3 (2A)
- net wd_dirc: now reaches U9.17 (DIRC)
- net wd_dirc: now also U8.5 (3A)
- net CR/W: now reaches U9.2 (R/~{W})
- net CR/W: now also U1.25 (CR/~{W})
- net wd_mo: now reaches U9.20 (MO)
- net wd_mo: now also U8.13 (6A)
- net wd_wg: now reaches U9.21 (WG)
- net wd_wg: now also U8.9 (4A)
- net wd_wd: now reaches U9.22 (WD)
- net wd_wd: now also U8.11 (5A)
- net FDC_INT: now reaches U9.28 (INTRQ)
- net at L?.1: now also U8.8 (4Y)
- net DRQ: now reaches U8.1 (1A)
- net at U8.10 (5Y): now also R100.2
- net at U8.4 (2Y): now also R101.2
- net at L?.1: now also R100.1
- net at L?.1: now also R101.1
Other:
- note added: "From J2"
- note added: "From/To U1"
- note added: "To U1"
- note added: "To U8"
- note added: "To U9"
- note removed: "DRQ"
- moved on the sheet: U8

Commit message: finition de la fiche, rajout de pwr_flag sur presque tous les points filtrés
Parts:
- added R13, R14, R15: 1K, symbol Device:R_Small_US
- added R16: 220, symbol Device:R_Small_US
- gave numbers to parts that had none: 11
- renumbered L55 to L66
Connections:
- net DMA_RW is gone; now on net CR/W: J2.18 (Pin_18)
- net +5V: now also R13.2, R14.2, R15.2, R16.2
- net index: now also R15.1
- net track_00: now also R14.1
- net write_protect: now also R13.1
- net at L66.1, U9.19 (~{RD}): now also R16.1
Other:
- note added: "ACK"
- note added: "CS"
- note added: "To U40"
- moved on the sheet: R102, R103

Commit message: fixed symbols causing DRC errors, fixed renamed symbol 'FerriteBead_small'
Parts:
- L24: symbol Device:Ferrite_Bead_Small -> Device:FerriteBead_Small
Changed lines of the file:
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@@
     (pin "3")
   )
-  (symbol (lib_id "Device:Ferrite_Bead_Small") (at 88.9 35.56 270) (unit 1)
+  (symbol (lib_id "Device:FerriteBead_Small") (at 88.9 35.56 270) (unit 1)
     (in_bom yes) (on_board yes)
     (property "Reference" "L24" (id 0) (at 83.82 34.29 90)
